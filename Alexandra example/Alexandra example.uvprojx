# Keil uVision project Alexandra example.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Alexandra example
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./src/: stm32f746xx_FLASH.h stm32f746xx_GPIO.h stm32f746xx_RCC.h stm32f746xx_TIM.h stm32f746xx_USART.h main.c stm32f746xx_RCC.c
    ./: stm32f746xx_GPIO.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.2.5
